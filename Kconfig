## Kconfig
```kconfig
# Copyright (c) 2026 Brandon Edmonds
# SPDX-License-Identifier: Apache-2.0

rsource "drivers/icm20948/Kconfig"
```
